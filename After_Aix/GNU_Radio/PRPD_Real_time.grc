options:
  parameters:
    author: yousef BENSOUDANE
    generate_options: qt_gui
    id: PRPD_Real_time
    output_language: python
    title: CISTEME PRPD
  states: {}

blocks:
- name: freq_center
  id: variable_qtgui_range
  parameters:
    min_len: '100'
    start: start_f
    step: samp_rate * 0.8
    stop: 2000e6-(samp_rate/2)
    value: start_f
  states: {}
- name: freq_center_p
  id: variable
  parameters:
    value: 100e6
  states: {}
- name: freq_center_test
  id: variable_qtgui_range
  parameters:
    min_len: '100'
    start: start_f
    step: ((2000e6-(samp_rate/2))-start_f)/1
    stop: 2000e6-(samp_rate/2)
    value: start_f
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    min_len: '100'
    start: '0'
    step: '5'
    stop: '76'
    value: '40'
  states: {}
- name: pnt
  id: variable
  parameters:
    value: '8'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 12e6
  states: {}
- name: start_f
  id: variable
  parameters:
    value: 106e6
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import sys

      sys.path.append("/home/yousef/Documents/testing_scripts/GEVernova/After_Aix/GNU_Radio")

      from prpd_phase_amp_block import blk
    cutoff_if: 5.9e6
    f_offset: 5e6
    f_ref: '50'
    min_distance_us: '10'
    phase_offset_deg: '0'
    samp_rate: samp_rate
    t_start: '1'
    threshold_factor: '4'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: '"PRPD"'
    size: 1024*pnt
    type: complex
    xmax: '360'
    xmin: '0'
    ymax: '10'
    ymin: '-70'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: freq_center
    fftsize: '32768'
    grid: 'True'
    name: '"Input Spectre"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Input in Time Domain"'
    size: 1024*pnt
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq_center
    fftsize: '512'
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq_center
    fftsize: '4096'
    name: '"Spectogram"'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: freq_center
    clock_source0: internal
    gain0: gain
    samp_rate: samp_rate
    sync: pc_clock_next_pps
    time_source0: external
    type: fc32
  states: {}

connections:
- [blocks_float_to_complex_0, '0', qtgui_const_sink_x_0, '0']
- [epy_block_0, '0', blocks_float_to_complex_0, '0']
- [epy_block_0, '1', blocks_float_to_complex_0, '1']
- [uhd_usrp_source_0, '0', epy_block_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
